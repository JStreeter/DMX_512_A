# Keil uVision project DMX.uvproj, settings and files
target DMX (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: DMX +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: ..\DMX_512_A;C:\ti\TivaWare_C_Series-2.1.1.71
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup_TM4C123.s Serial.c Timers.c
  group Header
    ./: main.h Serial.h globals.h
    C:/Keil/ARM/Pack/Keil/TM4C_DFP/1.0.0/Device/Include/TM4C123/: TM4C123GH6PM.h
  group Driver
    C:/ti/TivaWare_C_Series-2.1.1.71/driverlib/: adc.c comp.c cpu.c eeprom.c flash.c gpio.c i2c.c interrupt.c pwm.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c
  group Driver Header
    C:/ti/TivaWare_C_Series-2.1.1.71/driverlib/: adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h i2c.h interrupt.h lcd.h mpu.h onewire.h pin_map.h pwm.h qei.h readme.txt rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h uart.h udma.h usb.h watchdog.h
  group Hw Header
    C:/ti/TivaWare_C_Series-2.1.1.71/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h
